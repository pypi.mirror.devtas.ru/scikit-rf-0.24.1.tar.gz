!Created with skrf (http://scikit-rf.org).
# GHz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (one-way two-port):
!   201 points, 1 GHz to 100 GHz, reference 50 ohm
!   highest |S21| = -49.69 dB at 14.86 GHz (marker M1); lowest = -95.1 dB at 84.66 GHz (marker M2)
!   lowest |S11| = -13.8 dB at 96.53 GHz (marker M3), VSWR 1.51, Z = 33.4 + j3.51 ohm
!   |S11| at or under -10 dB: 71.55 GHz to 72.28 GHz (735.1 MHz wide, 1.02 % of centre); 90.96 GHz to 92.2 GHz (1.239 GHz wide, 1.35 % of centre); 95.75 GHz to 97.38 GHz (1.633 GHz wide, 1.69 % of centre) (the widest 3 of 28)
!   |S22| runs from -17.2 to -1.2 dB; largest |S21 - S12| = 0.004
!   the Smith chart shows 93.56 GHz to 100 GHz only
!   S11 on the Smith chart (normalised r, x): 93.56 GHz: 0.89, +0.52; 96.53 GHz: 0.67, +0.07; 97.53 GHz: 1.51, -0.65; 99.01 GHz: 1.94, -0.28; 100 GHz: 0.78, +0.35
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 1 GHz  -1.1  -76.3  -63.7  -1.4
! 5.95 GHz  -2.7  -53.6  -65.4  -3.4
! 7.435 GHz  -2.8  -84.1  -73.8  -4.3
! 8.425 GHz  -3.5  -51.4  -67.3  -3.2
! 13.87 GHz  -3.7  -80.2  -61.6  -4.4
! 14.86 GHz  -4.9  -49.7  -67.6  -3.9
! 17.34 GHz  -4.4  -82.9  -56.7  -4.9
! 17.83 GHz  -5.6  -57.4  -79.0  -4.6
! 28.23 GHz  -5.8  -92.9  -58.6  -5.7
! 34.16 GHz  -7.8  -54.8  -58.8  -7.5
! 35.65 GHz  -7.4  -80.3  -63.5  -8.9
! 36.15 GHz  -7.7  -54.8  -64.4  -7.4
! 50.5 GHz  -9.4  -58.5  -67.3  -11.1
! 67.33 GHz  -9.9  -72.2  -68.1  -8.3
! 83.67 GHz  -11.4  -66.3  -56.5  -8.8
! 84.66 GHz  -10.7  -95.1  -57.7  -11.0
! 85.15 GHz  -12.6  -56.4  -71.7  -9.3
! 93.56 GHz  -11.4  -84.6  -62.6  -14.1
! 96.53 GHz  -13.8  -64.6  -85.4  -16.8
! 97.53 GHz  -9.9  -58.7  -82.1  -12.8
! 99.01 GHz  -9.6  -56.3  -67.4  -15.9
! 100 GHz  -12.8  -58.9  -65.7  -10.1
